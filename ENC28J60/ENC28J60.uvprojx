# Keil uVision project ENC28J60.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ENC28J60
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Src;.\uip;.\uipapp;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Src/: delay.c led.c main.c stm32f10x_it.c uart.c emc28j60_uip.c ENC28J60.C SPI.C
  group uip
    ./uip/: psock.c tapdev.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uipapp
    ./uipapp/: httpd.c httpd-cgi.c httpd-fs.c httpd-fsdata.c http-strings.c tcp_demo.c udp_demo.c
software components: CMSIS:CORE 4.1.0, Device:GPIO 1.01.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
